Commit message: fix head urdf joint polarity

File: src/alfie_urdf/urdf/alfiebot.urdf (robot description, URDF)
Before this commit: robot alfiebot, 23 links, 22 joints
Joints:
- joint head_pitch_joint: axis 0. 0. -1. -> 0. 0. 1.
- joint head_yaw_joint: axis 0. 0. 1. -> 0. 0. -1.
